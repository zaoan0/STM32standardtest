# Keil uVision project stm32zhanjianstandard.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32zhanjianstandard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\CORE;.\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: stm32f10x_it.c main.c delay.c motor.c grayscale.c mpu6050.c lcd.c touch.c debug.c pid.c encoder.c tracking.c ui.c lcd.h touch.h delay.h motor.h grayscale.h mpu6050.h debug.h tracking.h ui.h
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_adc.c
